# Keil uVision project workingCode.uvprojx, settings and files
target workingCode (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: workingCode
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: RVMDK PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1
  c include: C:\ti\TivaWare_C_Series-2.1.2.111
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    C:/ti/: startup_rvmdk.S
    ./: main.c MotorControl.c MotorControl.h PWM.c PWM.h pwmForServo.c pwmForServo.h sysTickDelay.c sysTickDelay.h timerInitialization.c timerInitialization.h uartstdio.c uartstdio.h gyroMpu6050.c i2c.c
  group Library
    C:/ti/TivaWare_C_Series-2.1.2.111/driverlib/rvmdk/: driverlib.lib
